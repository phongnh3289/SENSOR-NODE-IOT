# Keil uVision project 01-EXAMPLE_HTTP_RTOS.uvprojx, settings and files
target STM32F4_DISCOVERY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F407xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F4_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=336,RCC_PLLP=2,RCC_PLLQ=7,
  c include: .\User;.\TM;..\00-STM32_LIBRARIES;..\00-HAL_DRIVERS\STM32F4xx_HAL_Driver\Inc;..\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-HAL_DRIVERS\CMSIS\Include;..\00-GSM_LIBRARY;..\00-GSM_LIBRARY\pt;..\00-STM32_LIBRARIES\FreeRTOS\include;..\00-STM32_LIBRARIES\FreeRTOS\CMSIS_RTOS;..\00-STM32_LIBRARIES\FreeRTOS\portable\RVDS\ARM_CM4F;..\00-STM32_LIBRARIES\drivers;..\00-STM32_LIBRARIES\drivers;..\00-STM32_LIBRARIES\option;..\00-STM32_LIBRARIES\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group STM32F4_Startup
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xc.s startup_stm32f401xe.s startup_stm32f407xx.s startup_stm32f411xe.s startup_stm32f429xx.s startup_stm32f439xx.s startup_stm32f446xx.s
  group STM32F4_HAL_Drivers
    ../00-HAL_DRIVERS/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group TM
    ../00-STM32_LIBRARIES/: tm_stm32_buffer.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_dma.c tm_stm32_general.c tm_stm32_gpio.c tm_stm32_rcc.c tm_stm32_rtc.c tm_stm32_usart.c tm_stm32_usart_dma.c tm_stm32_adc.c tm_stm32_ds18b20.c tm_stm32_onewire.c
  group User
    ./User/: main.c stm32fxxx_it.c system_stm32f4xx.c
  group GSM
    ../00-GSM_LIBRARY/: gsm.c buffer.c
    ./User/: gsm_ll.c
  group FreeRTOS
    ../00-STM32_LIBRARIES/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../00-STM32_LIBRARIES/FreeRTOS/portable/RVDS/ARM_CM4F/: port_cm4.c
    ../00-STM32_LIBRARIES/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../00-STM32_LIBRARIES/FreeRTOS/portable/MemMang/: heap_4.c
